Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-09T14:24:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 09 14:24:31 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{E5E26E7A-255E-4A00-96D6-4E39D6F91787}\ifc * Database version: 5507 * Database creation date: Mon Aug 09 14:24:31 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 09 14:24:31 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 09 14:24:31 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5667 Washbasin faucet, 5667(2021):5667 Washbasin faucet:349129
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 208.764 mm; NominalHeight: 100.184 mm; NominalWidth: 289.137 mm
Type - General - Author: BIMstone; BIMObjectName: 5667(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 21/07/2021
Type - Green Building Properties - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150098567; EN Standard: EN 1111; LVI Number: 6110352; Noise Class: I (ISO 3822); RSK Number: 8325279
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5667; Catalog Drawing URL: http://static.oras.com/catdrw/5667; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/5667; FDV Document URL: http://www.oras.com/datasheet/5667/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5667; Group: Washbasin faucets; Long Marketing: Thermostatic wall-mounted washbasin faucet with long ergonomic flow handles. Temperature handle equipped with safety lock. Volume handle with EcoFlow control. The faucet is equipped with thermal disinfection. The faucet includes litter filters and non-return valves.; Manufacturer: Oras; Market: INT;FIN;SWE; Model: 5667 Washbasin faucet; Name_en: 5667 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 407 x 265 x 119; Package Weight: 3.031 kg; Product Code: 5667; Product Datasheet: http://www.oras.com/datasheet/5667/en; Product Family: Oras Clinica; Product Image URL: http://static.oras.com/image/5667; Product URL: http://static.oras.com/5667; Technical DataSheet URL: http://www.oras.com/datasheet/5667/en; Type Name: 5667 Washbasin faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: DZR brass;Waterways without nickel coating; Connection: DirectConnection; Connection Size: G3/4; Flow Rate At 300kPa: 0.00670979 m3/s; Installation and Maintenance: http://static.oras.com/manual/5667; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Long lever;; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part;;Non-return valve(s);Litter filter(s); Spare Parts: http://static.oras.com/sp/5667; Temperature Adjustments: THERMO COOL
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5667(2021); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5667; Name: 5667 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 280x190x100 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.108517 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0056076 m3
Identity Data - Mark: 3
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5667(2021): 5667 Washbasin faucet; Family and Type: 5667(2021): 5667 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5667(2021): 5667 Washbasin faucet; Type Id: 5667(2021): 5667 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
